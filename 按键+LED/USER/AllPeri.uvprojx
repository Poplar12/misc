# Keil uVision project AllPeri.uvprojx, settings and files
target peripheral (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE;..\FWLIB\inc;..\HARDWARE\LCD;..\OS;..\BUTTON;..\HARDWARE\KEY;..\LED;..\QUE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c task1.c task2.c task3.c
  group HARDWARE
    ../HARDWARE/UART/: uart.c
    ../HARDWARE/BaseTime/: basetime.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: bsp_led.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_tim.c stm32f4xx_rng.c
  group OS
    ../OS/: os.c
  group BUTTON
    ../BUTTON/: button.c
  group LED
    ../LED/: led.c
  group QUE
    ../QUE/: que.c
